# IAR project xuanzhuandaolibai.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: CC.h Global.h GUI.c GUI.h keyboard.c keyboard.h main.c main.h Motor.c Motor.h PID.c PID.h PWM.c PWM.h RotaryEncoder.c RotaryEncoder.h TFT.c TFT.h TFT_Menu.c TFT_Menu.h TimerA1.c TimerA1.h TimerB0.c TimerB0.h UART.c UART.h UCS.c UCS.h WDT.c WDT.h zifu8x12.h
